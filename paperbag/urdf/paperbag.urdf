Commit message: Updated paper bags to have collisions for manipulation

File: paperbag/urdf/paperbag.urdf (robot description, URDF)
Before this commit: robot paperbag, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.12 0.30 0.20; collision cylinder length=0.06 radius=0.005
